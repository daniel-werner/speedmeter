# IAR project speedmeter.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1612 MSP430F1612
  General.GStackSize2: 1000
  General.GHeapSize2: 1024
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; inc
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: setup\lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 768
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1612.xcl
  group inc/flash
    inc/flash/: flash_manager.h
  group inc/gui
    inc/gui/: available_fonts.h display.h font.h font_manager.h pixel.h
  group inc/gui/displayobjects
    inc/gui/displayobjects/: bitmap.h character.h circle.h display_object.h line.h mask.h point.h rectangle.h text.h
  group inc/gui/drivers
    inc/gui/drivers/: display_driver.h PCD_8544_driver.h PCF_8548_driver.h
  group inc/gui/fonts
    inc/gui/fonts/: arial_11.h arial_14.h calibri_11.h calibri_14.h ms_sans_serif_11.h
  group inc/gui/images
    inc/gui/images/: about_image.h background.h base.h clock_image.h gauge.h lcd.h settings_image.h
  group inc/init
    inc/init/: hardware_init.h
  group inc/init/io
    inc/io/: i2c_device.h interrupt_device.h io_device.h spi_device.h
  group inc/io
    inc/io/: speed_meter.h
  group inc/menu
    inc/menu/: about.h keyboard.h menu.h menu_edit.h menu_selector.h menu_states.h
  group inc/menu/icons
    inc/menu/icons/: diameter.h splash.h
  group inc/system
    inc/system/: settings.h system.h
  group inc/timer
    inc/timer/: date.h history.h rtc.h time.h timer.h
  group inc/watchdog
    inc/watchdog/: watchdog.h
  group setup
    setup/: board.h setup.h
  group src
    ./: main.c
  group src/flash
    src/flash/: flash_manager.c
  group src/gui
    src/gui/: display.c font_manager.c
  group src/gui/displayobjects
    src/gui/displayobjects/: bitmap.c character.c circle.c display_object.c line.c mask.c point.c rectangle.c text.c
  group src/gui/drivers
    src/gui/drivers/: PCF_8548_driver.c
  group src/init
    src/init/: hardware_init.c
  group src/io
    src/io/: i2c_device.c interrupt_device.c speed_meter.c spi_device.c
  group src/menu
    src/menu/: about.c keyboard.c menu.c menu_edit.c menu_selector.c menu_states.c
  group src/system
    src/system/: settings.c system.c
  group src/timer
    src/timer/: date.c history.c rtc.c time.c timer.c
  group src/watchdog
    src/watchdog/: watchdog.c
  group types
    types/: bcd.c bcd.h buffer.c buffer.h matrix.c matrix.h string.c string.h types.h vector.c vector.h
